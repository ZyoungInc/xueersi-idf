# Keil uVision project cdc_acm.uvprojx, settings and files
target VirtualSerialPort (6240000::V6.24::ARMCLANG)
  device: GD32F350G8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.4.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VirtualSerialPort +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F350
  c include: ..\inc;..\..\Firmware\GD32F3x0_standard_peripheral\Include;..\..\Firmware\GD32F3x0_usbfs_library\device\core\Include;..\..\Firmware\GD32F3x0_usbfs_library\device\class\cdc\Include;..\..\Firmware\GD32F3x0_usbfs_library\ustd\common;..\..\Firmware\GD32F3x0_usbfs_library\ustd\class\cdc;..\..\Firmware\CMSIS\GD\GD32F3x0\Include;..\..\Firmware\GD32F3x0_usbfs_library\driver\Include;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../src/: app.c gd32f3x0_hw.c gd32f3x0_it.c
  group CMSIS
    ../src/: system_gd32f3x0.c
  group GD32F3x0_StdPeriph_Driver
    ../../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group User
    ../../User/: gd32f350r_eval.c
  group USB_Drivers
    ../../Firmware/GD32F3x0_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../Firmware/GD32F3x0_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../Firmware/GD32F3x0_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 6.2.0
